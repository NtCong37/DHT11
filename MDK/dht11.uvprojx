# Keil uVision project dht11.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dht11 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\MyLib\inc;.\MyLib\src
  asm include: .\MyLib\src;.\MyLib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../USER/: main.c
  group mylib
    ./MyLib/src/: timer.c uart.c dht11.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
